# Keil uVision project Project.uvproj, settings and files
target ZFWL_V1.0 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=4 OneElfS=1
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\USER\ucCos_App;..\USER\uC-CPU;..\USER\uC-LIB;..\USER\uCOS-II;..\USER\uCOS-VIEW;..\Libraries\STM32_ETH_Driver\inc;..\USER\lwip-1.3.2;..\USER\lwip-1.3.2\src;..\USER\lwip-1.3.2\src\api;..\USER\lwip-1.3.2\src\netif;..\USER\lwip-1.3.2\src\core;..\USER\lwip-1.3.2\src\arch;..\USER\lwip-1.3.2\src\include;..\USER\lwip-1.3.2\src\core\ipv4;..\USER\lwip-1.3.2\src\include\lwip;..\USER\lwip-1.3.2\src\include\netif;..\USER\lwip-1.3.2\src\include\arch;..\USER\lwip-1.3.2\src\include\ipv4\lwip;..\USER\GLCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../USER/: main.c stm32f10x_it.c stm32f10x_conf.h i2c_fram.c i2c_fram.h
    ../USER/ucCos_App/: uctsk_OSView.c app_cfg.h includes.h uctsk_SSNP_TBIM.c uctsk_SSNP_TBC.c commondefine.h upcomputer.c upcomputer.h
  group GLCD
    ../USER/GLCD/: HzLib.c AsciiLib.c GLCD.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32_ETH_Driver
    ../Libraries/STM32_ETH_Driver/src/: stm32_eth.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group uC-OS-II/Port
    ../USER/uCOS-II/Ports/ARM-Cortex-M3/RealView/: os_dbg.c os_cpu_c.c os_cpu.h os_cpu_a.asm
  group uC-OS-II/Source
    ../USER/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Config
    ../USER/ucCos_App/: OS_AppHooks.c os_cfg.h
  group uC-OS-II/CPU
    ../USER/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm cpu.h
    ../USER/uC-CPU/: cpu_def.h
  group uC-OS-II/LIB/Source
    ../USER/uC-LIB/: lib_mem.c lib_str.c lib_def.h lib_mem.h lib_str.h
  group uC-OS-II/LIB/Port
    ../USER/uC-LIB/Ports/RealView/: lib_mem_a.asm
  group uC-OS-II/VIEW/Source
    ../USER/uCOS-VIEW/Source/: os_view.c os_view.h
  group uC-OS-II/VIEW/Port
    ../USER/uCOS-VIEW/Ports/ARM-Cortex-M3/Realview/: os_viewc.c os_viewc.h
  group ssnp
    ../USER/ssnp/: api_lib.c api_msg.c dp.c ethbcp.c ethernetif.c inet_chksum.c init.c mem.c memp.c netbuf.c netif.c pbuf.c ssnp.c sys_arch.c TBIM.c TEDS.c timer.c tp.c ssnp_for_app.c alias_map.c alias_state.c TBC.c TBIMDriver.c sdp.c teds_table.h teds_table.c
